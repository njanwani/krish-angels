Commit message: TODO: inv kin, detectors, poses

File: basic134/urdf/Robot_assembly.urdf (robot description, URDF)
Before this commit: robot Robot_assembly_gripper, 11 links, 10 joints
Joints:
- joint link1: origin xyz=0.2607 0.12618 0.11049 rpy=0 0 0 -> xyz=0.2607 0.12618 0.11049 rpy=0 0 -0.0
